# Keil uVision project 学生机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 简易计算器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 简易计算器.c buzzer.h buzzer.c xyv17b.h xyv17b.c
